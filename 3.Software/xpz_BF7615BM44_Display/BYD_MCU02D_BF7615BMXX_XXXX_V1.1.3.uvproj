# Keil uVision project BYD_MCU02D_BF7615BMXX_XXXX_V1.1.3.uvproj, settings and files
target BYD_MCU02D (MCS-51)
  device: BF7615BM44-LJTX BF7X15BMXX-XXXX
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFBFF) CLOCK(12000000)
  output: BYD_MCU02D_BF7615BMXX_XXXX_V1_1_3 +hex
  c flags: Optimize=3 SizeSpeed=1
  c include: .\Application_Library;.\BF7615BMXX_XXXX_Library;.\Code;.\Project;.\Hardware
  link misc: REMOVEUNUSED
  group A51&&UpdataLog
    ./: STARTUP.A51
    ./Document/: ReadMe_UpdateLog.txt
  group Project
    ./Project/: Project.c
    ./BF7615BMXX_XXXX_Library/: Touch_MCU_Init.c Config.c main.c
  group BF7615BMXX_XXXX_API
    ./BF7615BMXX_XXXX_Library/BF7615BMXX_XXXX_API_Lib/: BF7615BMXX_XXXX_API_Timer.c BF7615BMXX_XXXX_API_LVDT.c BF7615BMXX_XXXX_API_UART.c
  group BF7615BMXX_XXXX_CTK_Lib
    ./BF7615BMXX_XXXX_Library/BF7615BMXX_XXXX_CTK_Lib/: BF7615BMXX_XXXX_CTK.c BF7615BMXX_XXXX_CTK_Touch.c BF7615BMXX_XXXX_CTK_Trace.c BF7615BMXX_XXXX_CS_DataDeal_V1_0_0.LIB BF7615BMXX_XXXX_CTK_Idle.c
  group Code
    ./Code/: View.c Cmd.c crc.c
  group Hardware
    ./Hardware/: SysTime.c SM16306SJ.c Key_Function.c Led.c Display_Function.c
